require linux-yocto-srp.inc
